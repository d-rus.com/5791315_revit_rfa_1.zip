Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilets_DURAVIT_ME-by-Starck-wall-mounted-toilet-251009.ifc
Time: 2020-02-07T10:33:10
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: ME by Starck wall-mounted toilet 251009
ePset_BIMobjectScript - Color: 20 HygieneGlaze; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): ME by Starck wall-mounted toilet 251009; SKU (BO_prodsku): me-by-starck-wall-mounted-toilet-251009; ManufacturName (BO_Manufac): DURAVIT; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): ME by Starck; ProductGroup (BO_prodgroup): toilet; EditionNumber (BO_edinum): 1; Width (BO_width): 360; Height (BO_height): 422; Depth (BO_depth): 575; Weight (BO_weight): 25; QR (BO_boqrurl): http://bimobject.com/duravit/product/me-by-starck-wall-mounted-toilet-251009; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/me-by-starck-wall-mounted-toilet-251009; ProductUrl (BO_producturl): http://pro.duravit.com/p/251009; InstallationInstructions (BO_montins): http://pro.duravit.com/p/251009; ProductCertification (BO_prodcert): http://pro.duravit.com/p/251009; TechnicalDescription (BO_techcert): http://pro.duravit.com/p/251009; InstructionVideo (BO_youtube): http://pro.duravit.com/p/251009; GtinCode (BO_gtin): 4053424894287; MaterialMain (BO_mainmat): Ceramics; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Toilets; BimObjectCategoryCode (BO_bocat_code): sanitary-toilets; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspscCode (BO_unspsc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L7216; Uniclass14Description (BO_uniclass_1_4_desc): Toilets; Uniclass20Code (BO_uniclass_2_0_code): SS-35-65-90; Uniclass20Description (BO_uniclass_2_0_desc): Toilet Systems; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_93; Uniclass2015Description (BO_uniclass2015_desc): Urinal and WC fittings; NBSReference (BO_nbs_ref): 35-65-90; NBSReferenceDescription (BO_nbs_desc): Toilet Systems; OmniClassCode (BO_omniclass_code): 23-31 19 00; OmniClassDescription (BO_omniclass_name): Toilets; MasterFormat2014Code (BO_masterformat2014_code): 01 52 19; MasterFormat2014Description (BO_masterformat2014_name): Sanitary Facilities; UniFormat2Code (BO_uniformat2_code): D2030; UniFormat2Description (BO_uniformat2_name): Sanitary Waste; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
